
SRC_URI = "git://github.com/ayufan-rock64/rkbin;protocol=git;branch=master"

#SRCREV = "${AUTOREV}"
SRCREV = "af17d09dee19b41f4f01e1722eaf6911fb296245"
